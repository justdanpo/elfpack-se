# IAR project save_ttbl.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: PATCHRIGHTS
  ICCARM.CCIncludePath2: ..\classlib\fixedstd
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: PATCHRIGHTS; REALADDR
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group (top)
    ../classlib/: cl.cpp cl.h
    ./: common.asm commonc.h consts.h main.cpp
    ../include/: func.asm
    ../deleaker/: mem2.cpp mem2.h

# IAR project dlgredirect.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.PreInclude: ..\deleaker\mem2.h
  ICCARM.CCIncludePath2: ..\classlib\fixedstd
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\classlib\fixedstd
  group (top)
    ../classlib/: cl.cpp cl.h strutils.cpp strutils.hpp
    ../include/: func.asm
    ./: main.cpp mybook.cpp mybook.h mydisp.cpp mydisp.hpp
    ../deleaker/: mem2.cpp mem2.h

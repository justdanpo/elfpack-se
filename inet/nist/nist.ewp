# IAR project nist.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: OLDFUNCTIONS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS
  group (top)
    ../../classlib/: cl.cpp cl.h
    ./: conf_loader.cpp conf_loader.h config_data.c config_data.h elfcount.c elfcount.h inetpc.cpp mybook.cpp mybook.h updatetime.cpp updatetime.h wrappers.cpp wrappers.hpp
    ../../include/: func.asm
    ../../deleaker/: mem2.cpp

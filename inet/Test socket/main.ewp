# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\include\1.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  ICCARM.CCDefines: NDEBUG
  group (top)
    ../../C++/: _cpp2.cpp
    ./: Callbacks.c Callbacks.h main.c main.h
    ../../include/: func.asm

# IAR project DirectoryEditor.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: dirlist.cpp dirsettings.cpp editname.cpp editor.cpp main.cpp selectdir.cpp selecticons.cpp setstate.cpp
    ../include/: func.asm
    ../deleaker/: mem2.cpp mem2.h

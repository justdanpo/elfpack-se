# IAR project musicservercallback.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: OLDFUNCTIONS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS
  group (top)
    ../classlib/: cl.cpp cl.h
    ./: elfcount.c elfcount.h main.cpp mybook.cpp mybook.h
    ../include/: func.asm
    ../deleaker/: mem2.cpp mem2.h

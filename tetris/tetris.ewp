# IAR project tetris.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS
  XLINK.XclFile: ..\include\1.xcl
configuration Release_RUS (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ENG_LANG; NDEBUG; OLDFUNCTIONS
  XLINK.XclFile: ..\include\1.xcl
  group (top)
    ../C++/: _cpp2.cpp
    ./: ActionList.c ActionList.h Button.c Button.h Color.c Color.h DataBrowser.c DataBrowser.h ErrorIAR.c ErrorIAR.h Game.c Game.h main.c Menu.c Menu.h MyFUNC.c MyFUNC.h NewRecord.c NewRecord.h OpenNastroiki.c OpenNastroiki.h Pages.h rand.c rand.h Rec_Check.c Rec_Check.h Save.c Save.h StructBook.h
    ../include/: func.asm

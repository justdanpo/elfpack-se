# IAR project runtime_vkp.ewp, settings and files
configuration Release_3150_R1 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS; DB3150_R1
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: DB3150_R1
  XLINK.XclFile: ..\include\1.xcl
configuration Release_3150_R2 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS; DB3150_R2
  AARM.ADefines: DB3150_R2
configuration Release_3150_R2_NEW (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS; DB3150_NEW
  AARM.ADefines: DB3150_NEW
configuration Release_3210 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS; DB3200; DB3210
  AARM.ADefines: DB3200; DB3210
configuration Release_3350 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS; DB3350
  AARM.ADefines: DB3350
configuration Release_C702 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS; DB3150_R2; C702_R3EF001
  AARM.ADefines: DB3150_R2
  group (top)
    ../C++/: _cpp2.cpp
    ./: conf_loader.cpp config_data.c cp15.asm main.c patch_pcore.asm
    ../include/: func.asm

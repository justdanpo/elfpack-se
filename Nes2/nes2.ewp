# IAR project nes2.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: include
  group (top)
    ../C++/: _cpp2.cpp
    ./: book.cpp conf_loader.cpp config_data.c gui.cpp lang.c main.cpp nes.cpp
    ../include/: func.asm
  group nes9x
    nes9x/: M6502.C MAPPER.C nes9x.c

# IAR project FindFiles.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: OLDFUNCTIONS
  ICCARM.PreInclude: ..\deleaker\mem2.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS
  group (top)
    ./: CGuiFindList.c CGuiFolderList.c CMyBook.c FolderOpen.c InputPageAndGuiInput.c main.c mcl.h OtherFunctions.c
    ../classlib/: cl.cpp cl.h
    ../include/: func.asm
    ../deleaker/: mem2.cpp

# IAR project BookManagerMod.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.PreInclude: ..\deleaker\mem2.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: book_names.c book_names.h bookparam.c bookparam.h conf_loader.cpp conf_loader.h config_data.c config_data.h def_func.h folders.c main.c main.h phone.c phone.h shortcuts.c shortcuts.h util.h utils.c
    ../include/: func.asm
    ../deleaker/: mem2.cpp mem2.h

# IAR project elf-menu.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.PreInclude: inc.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.PreInclude: ..\\deleaker\mem2.h
  group (top)
    ./: cache.c CFile.cpp CFile.h config.c draw_lib.c draw_lib.h edit.c execute.c extern.h folder.c graph.c history.c hook.c image.cpp keyhook.c lang.c link.c list.c main.c menu.c menu_gui.c options.c ru.h skin.c style.c style_load.c utils.c
    ../include/: func.asm
    ../deleaker/: mem2.cpp

# IAR project Cubes.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: OLDFUNCTIONS
  ICCARM.PreInclude: C:\FTP\UPLOAD\ELFS\svn\deleaker\mem2.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS
  ICCARM.PreInclude: ..\deleaker\mem2.h
  group (top)
    ./: CCube.c CGame.c CGameDisp.c CGuiMainMenu.c CGuiRecordMenu.c CMyBook.c Code_Huffman.c CPoint.c main.c rand.c
    ../classlib/: cl.cpp
    ../include/: func.asm
    ../deleaker/: mem2.cpp

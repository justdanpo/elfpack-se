<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MiniGPS.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>MiniGPS</project>
        <configuration>Release_EN</configuration>
      </member>
      <member>
        <project>MiniGPS</project>
        <configuration>Release_RU</configuration>
      </member>
      <member>
        <project>MiniGPS</project>
        <configuration>Release_CN</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



# IAR project NewFile.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.PreInclude: ..\deleaker\mem2.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NDEBUG
  group (top)
    ../classlib/: cl.cpp cl.h
    ./: file.cpp file.h gui.cpp gui.h main.cpp mybook.cpp mybook.h NOfMany.cpp NOfMany.h quicksort.cpp quicksort.h softkeys.cpp softkeys.h
    ../include/: func.asm
    ../deleaker/: mem2.cpp mem2.h

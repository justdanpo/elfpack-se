# IAR project ElfPack.ewp, settings and files
configuration C510_R1FA035_Orange (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration C510_R1HA035 (ARM)
  as the first configuration, except:
configuration C702_R3EF001 (ARM)
  as the first configuration, except:
configuration C901_R1GA028 (ARM)
  as the first configuration, except:
configuration C902_R3EG004AO (ARM)
  as the first configuration, except:
configuration C902_R3EG004AS (ARM)
  as the first configuration, except:
configuration C903_R1GA028 (ARM)
  as the first configuration, except:
configuration C905_R1FA035 (ARM)
  as the first configuration, except:
configuration F100_R1HA035 (ARM)
  as the first configuration, except:
configuration G502_R1FA037_Hutchison (ARM)
  as the first configuration, except:
configuration J105_R1GA026_Orange (ARM)
  as the first configuration, except:
configuration J105_R1HA035 (ARM)
  as the first configuration, except:
configuration K510_R4EA031 (ARM)
  as the first configuration, except:
configuration K510_R4EC001 (ARM)
  as the first configuration, except:
configuration K530_R8BB001 (ARM)
  as the first configuration, except:
configuration K550_R6BC002 (ARM)
  as the first configuration, except:
configuration K550_R8BA024 (ARM)
  as the first configuration, except:
configuration K600_R2BB001 (ARM)
  as the first configuration, except:
configuration K610_R8BE001 (ARM)
  as the first configuration, except:
configuration K630_R1FA032 (ARM)
  as the first configuration, except:
configuration K660_R1FA037_Hutchison (ARM)
  as the first configuration, except:
configuration K750_R1CA021 (ARM)
  as the first configuration, except:
configuration K770_R8BA024 (ARM)
  as the first configuration, except:
configuration K770_R8BC004 (ARM)
  as the first configuration, except:
configuration K790_R8BF003 (ARM)
  as the first configuration, except:
configuration K800_R8BF003 (ARM)
  as the first configuration, except:
configuration K810_R8BA024 (ARM)
  as the first configuration, except:
configuration K810_R8BA024_Orange_Gen (ARM)
  as the first configuration, except:
configuration K810_R8BF003 (ARM)
  as the first configuration, except:
configuration K850_R1FA035 (ARM)
  as the first configuration, except:
configuration S500_R8BE001 (ARM)
  as the first configuration, except:
configuration T650_R8BC004 (ARM)
  as the first configuration, except:
configuration T700_R3EG004 (ARM)
  as the first configuration, except:
configuration T707_R1FA035 (ARM)
  as the first configuration, except:
configuration T715_R1GA026 (ARM)
  as the first configuration, except:
configuration T715_R1HA035 (ARM)
  as the first configuration, except:
configuration W200_R4HA014 (ARM)
  as the first configuration, except:
configuration W300_R4EA031 (ARM)
  as the first configuration, except:
configuration W350_R11CA002 (ARM)
  as the first configuration, except:
configuration W380_R11CA002 (ARM)
  as the first configuration, except:
configuration W508_R1FA035 (ARM)
  as the first configuration, except:
configuration W550_R4CB020 (ARM)
  as the first configuration, except:
configuration W580_R6CA001_Orange (ARM)
  as the first configuration, except:
configuration W580_R8BE001 (ARM)
  as the first configuration, except:
configuration W580_R8BE001_Orange (ARM)
  as the first configuration, except:
configuration W595_R3EF001 (ARM)
  as the first configuration, except:
configuration W595_R3EG004_Orange (ARM)
  as the first configuration, except:
configuration W600_R7CA017 (ARM)
  as the first configuration, except:
configuration W600_R7CA017_GEN (ARM)
  as the first configuration, except:
configuration W610_R6BC002 (ARM)
  as the first configuration, except:
configuration W610_R6CA001_Orange (ARM)
  as the first configuration, except:
configuration W610_R8BA024 (ARM)
  as the first configuration, except:
configuration W660_R8BB001 (ARM)
  as the first configuration, except:
configuration W660_R8BB001_Orange (ARM)
  as the first configuration, except:
configuration W700_R1CA021 (ARM)
  as the first configuration, except:
configuration W705_R1GA031 (ARM)
  as the first configuration, except:
configuration W710_R1JC002 (ARM)
  as the first configuration, except:
configuration W715_R1GA030 (ARM)
  as the first configuration, except:
configuration W760_R3EF001 (ARM)
  as the first configuration, except:
configuration W760_R3EM001 (ARM)
  as the first configuration, except:
configuration W800_R1BD001 (ARM)
  as the first configuration, except:
configuration W810_R4DB005 (ARM)
  as the first configuration, except:
configuration W810_R4EA031 (ARM)
  as the first configuration, except:
configuration W830_R1KG001 (ARM)
  as the first configuration, except:
configuration W850_R1KG001 (ARM)
  as the first configuration, except:
configuration W880_R8BA024 (ARM)
  as the first configuration, except:
configuration W890_R1FA035 (ARM)
  as the first configuration, except:
configuration W902_R3EG004 (ARM)
  as the first configuration, except:
configuration W910_R1FA037 (ARM)
  as the first configuration, except:
configuration W980_R3EG004 (ARM)
  as the first configuration, except:
configuration W995_R1GA026 (ARM)
  as the first configuration, except:
configuration W995_R1HA035 (ARM)
  as the first configuration, except:
configuration Z310_R8BA024 (ARM)
  as the first configuration, except:
configuration Z530_R6DA001 (ARM)
  as the first configuration, except:
configuration Z550_R6CA009 (ARM)
  as the first configuration, except:
configuration Z550_R6GA004 (ARM)
  as the first configuration, except:
configuration Z610_R6DA001 (ARM)
  as the first configuration, except:
configuration Z710_R1JC002 (ARM)
  as the first configuration, except:
configuration Z750_R1FA030 (ARM)
  as the first configuration, except:
configuration Z770_R1FA035 (ARM)
  as the first configuration, except:
  group (top)
    ./: calls.asm calls.h dll.c dll.h elfloader.cpp elfloader.h helper.c helper.h InternalFunc.c regfile.c regfile.h swi.asm vars.c vars.h
  group ASM
    temp/: temp.asm

# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCIncludePath2: ..\classlib\fixedstd
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\classlib\fixedstd
  group (top)
    ../classlib/: cl.cpp cl.h
    ./: conf_loader.cpp conf_loader.h config_data.c config_data.h consts.h IUnknown.hpp main.cpp mybook.cpp mybook.h
    ../include/: func.asm
    ../deleaker/: mem2.cpp mem2.h

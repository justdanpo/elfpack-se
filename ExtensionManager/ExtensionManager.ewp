# IAR project ExtensionManager.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
configuration Release_3350 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; DB3350
  group (top)
    ../C++/: _cpp2.cpp
    ../include/: func.asm
    ./: main.cpp methods.cpp utils.cpp

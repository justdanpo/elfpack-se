# IAR project ExtensionEditor.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: editor.cpp ext_add.cpp ext_list.cpp ext_setting.cpp main.cpp select_elf.cpp select_folder.cpp set_icons.cpp
    ../include/: func.asm
    ../deleaker/: mem2.cpp mem2.h
